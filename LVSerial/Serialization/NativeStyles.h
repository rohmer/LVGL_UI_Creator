#pragma once
#include "LVObject.h"
#include "RuntimeFeatures.h"
#if LVSERIAL_USE_ADVANCED_KEYBOARD
#include <KeyboardVisibility.h>
#endif
#include "LVFont.h"
#include "ImageRecords.h"
#include <map>
#include <set>
#include <vector>
#include <algorithm>

#if LVGL_VERSION_MAJOR >= 9 || defined(LV_RUNTIME_PORTABLE)
// LVGL 9.6 exposes style values publicly, while enumerating the attached
// selectors requires the vendored style descriptors. Restoration uses public setters.
#if __has_include(<src/core/lv_obj_private.h>)
#include <src/core/lv_obj_private.h>
#endif
#if __has_include(<src/core/lv_obj_style_private.h>)
#include <src/core/lv_obj_style_private.h>
#endif
namespace Serialization
{
    class NativeStyles
    {
#if LVGL_VERSION_MAJOR == 8
        using RuntimeStyleCoordinate = lv_coord_t;
#else
        using RuntimeStyleCoordinate = int32_t;
#endif
        struct OwnedStyleData
        {
            std::map<uint32_t, std::vector<RuntimeStyleCoordinate>> columns;
            std::map<uint32_t, std::vector<RuntimeStyleCoordinate>> rows;
            std::map<uint32_t, lv_grad_dsc_t> gradients;
            std::map<std::pair<uint32_t, lv_style_prop_t>, SerializedImageSource> images;
        };
        struct Property { const char* name; lv_style_prop_t id; bool color; };
        inline static const Property properties[] = {
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"width", LV_STYLE_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"min_width", LV_STYLE_MIN_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"max_width", LV_STYLE_MAX_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"height", LV_STYLE_HEIGHT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"min_height", LV_STYLE_MIN_HEIGHT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"max_height", LV_STYLE_MAX_HEIGHT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"length", LV_STYLE_LENGTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"x", LV_STYLE_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"y", LV_STYLE_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"align", LV_STYLE_ALIGN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"transform_width", LV_STYLE_TRANSFORM_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"transform_height", LV_STYLE_TRANSFORM_HEIGHT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"translate_x", LV_STYLE_TRANSLATE_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"translate_y", LV_STYLE_TRANSLATE_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"translate_radial", LV_STYLE_TRANSLATE_RADIAL, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"transform_scale_x", LV_STYLE_TRANSFORM_SCALE_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"transform_scale_y", LV_STYLE_TRANSFORM_SCALE_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"transform_rotation", LV_STYLE_TRANSFORM_ROTATION, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"transform_pivot_x", LV_STYLE_TRANSFORM_PIVOT_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"transform_pivot_y", LV_STYLE_TRANSFORM_PIVOT_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"transform_skew_x", LV_STYLE_TRANSFORM_SKEW_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"transform_skew_y", LV_STYLE_TRANSFORM_SKEW_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"pad_top", LV_STYLE_PAD_TOP, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"pad_bottom", LV_STYLE_PAD_BOTTOM, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"pad_left", LV_STYLE_PAD_LEFT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"pad_right", LV_STYLE_PAD_RIGHT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"pad_row", LV_STYLE_PAD_ROW, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"pad_column", LV_STYLE_PAD_COLUMN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"pad_radial", LV_STYLE_PAD_RADIAL, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"margin_top", LV_STYLE_MARGIN_TOP, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"margin_bottom", LV_STYLE_MARGIN_BOTTOM, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"margin_left", LV_STYLE_MARGIN_LEFT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"margin_right", LV_STYLE_MARGIN_RIGHT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_color", LV_STYLE_BG_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_opa", LV_STYLE_BG_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_grad_color", LV_STYLE_BG_GRAD_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_grad_dir", LV_STYLE_BG_GRAD_DIR, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_main_stop", LV_STYLE_BG_MAIN_STOP, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_grad_stop", LV_STYLE_BG_GRAD_STOP, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"bg_main_opa", LV_STYLE_BG_MAIN_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"bg_grad_opa", LV_STYLE_BG_GRAD_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_image_opa", LV_STYLE_BG_IMAGE_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_image_recolor", LV_STYLE_BG_IMAGE_RECOLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_image_recolor_opa", LV_STYLE_BG_IMAGE_RECOLOR_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"bg_image_tiled", LV_STYLE_BG_IMAGE_TILED, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"border_color", LV_STYLE_BORDER_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"border_opa", LV_STYLE_BORDER_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"border_width", LV_STYLE_BORDER_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"border_side", LV_STYLE_BORDER_SIDE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"border_post", LV_STYLE_BORDER_POST, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"outline_width", LV_STYLE_OUTLINE_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"outline_color", LV_STYLE_OUTLINE_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"outline_opa", LV_STYLE_OUTLINE_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"outline_pad", LV_STYLE_OUTLINE_PAD, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"shadow_width", LV_STYLE_SHADOW_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"shadow_offset_x", LV_STYLE_SHADOW_OFFSET_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"shadow_offset_y", LV_STYLE_SHADOW_OFFSET_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"shadow_spread", LV_STYLE_SHADOW_SPREAD, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"shadow_color", LV_STYLE_SHADOW_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"shadow_opa", LV_STYLE_SHADOW_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"image_opa", LV_STYLE_IMAGE_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"image_recolor", LV_STYLE_IMAGE_RECOLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"image_recolor_opa", LV_STYLE_IMAGE_RECOLOR_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"line_width", LV_STYLE_LINE_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"line_dash_width", LV_STYLE_LINE_DASH_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"line_dash_gap", LV_STYLE_LINE_DASH_GAP, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"line_rounded", LV_STYLE_LINE_ROUNDED, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"line_color", LV_STYLE_LINE_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"line_opa", LV_STYLE_LINE_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"arc_width", LV_STYLE_ARC_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"arc_rounded", LV_STYLE_ARC_ROUNDED, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"arc_color", LV_STYLE_ARC_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"arc_opa", LV_STYLE_ARC_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"text_color", LV_STYLE_TEXT_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"text_opa", LV_STYLE_TEXT_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"text_letter_space", LV_STYLE_TEXT_LETTER_SPACE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"text_line_space", LV_STYLE_TEXT_LINE_SPACE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"text_decor", LV_STYLE_TEXT_DECOR, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"text_align", LV_STYLE_TEXT_ALIGN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"text_outline_stroke_color", LV_STYLE_TEXT_OUTLINE_STROKE_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"text_outline_stroke_width", LV_STYLE_TEXT_OUTLINE_STROKE_WIDTH, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"text_outline_stroke_opa", LV_STYLE_TEXT_OUTLINE_STROKE_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0)
            {"text_leading_trim", LV_STYLE_TEXT_LEADING_TRIM, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"blur_radius", LV_STYLE_BLUR_RADIUS, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"blur_backdrop", LV_STYLE_BLUR_BACKDROP, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"blur_quality", LV_STYLE_BLUR_QUALITY, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"drop_shadow_radius", LV_STYLE_DROP_SHADOW_RADIUS, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"drop_shadow_offset_x", LV_STYLE_DROP_SHADOW_OFFSET_X, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"drop_shadow_offset_y", LV_STYLE_DROP_SHADOW_OFFSET_Y, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"drop_shadow_color", LV_STYLE_DROP_SHADOW_COLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"drop_shadow_opa", LV_STYLE_DROP_SHADOW_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"drop_shadow_quality", LV_STYLE_DROP_SHADOW_QUALITY, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"radius", LV_STYLE_RADIUS, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"radial_offset", LV_STYLE_RADIAL_OFFSET, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"clip_corner", LV_STYLE_CLIP_CORNER, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"opa", LV_STYLE_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"opa_layered", LV_STYLE_OPA_LAYERED, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"color_filter_opa", LV_STYLE_COLOR_FILTER_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"recolor", LV_STYLE_RECOLOR, true},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3)
            {"recolor_opa", LV_STYLE_RECOLOR_OPA, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"anim_duration", LV_STYLE_ANIM_DURATION, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"blend_mode", LV_STYLE_BLEND_MODE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"layout", LV_STYLE_LAYOUT, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"base_dir", LV_STYLE_BASE_DIR, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"rotary_sensitivity", LV_STYLE_ROTARY_SENSITIVITY, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"flex_flow", LV_STYLE_FLEX_FLOW, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"flex_main_place", LV_STYLE_FLEX_MAIN_PLACE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"flex_cross_place", LV_STYLE_FLEX_CROSS_PLACE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"flex_track_place", LV_STYLE_FLEX_TRACK_PLACE, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"flex_grow", LV_STYLE_FLEX_GROW, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_column_align", LV_STYLE_GRID_COLUMN_ALIGN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_row_align", LV_STYLE_GRID_ROW_ALIGN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_cell_column_pos", LV_STYLE_GRID_CELL_COLUMN_POS, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_cell_x_align", LV_STYLE_GRID_CELL_X_ALIGN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_cell_column_span", LV_STYLE_GRID_CELL_COLUMN_SPAN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_cell_row_pos", LV_STYLE_GRID_CELL_ROW_POS, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_cell_y_align", LV_STYLE_GRID_CELL_Y_ALIGN, false},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"grid_cell_row_span", LV_STYLE_GRID_CELL_ROW_SPAN, false},
#endif
        };
        inline static std::vector<const lv_style_t*> transientStyles;
    public:
        static void IgnoreTransientStyle(const lv_style_t* style) { transientStyles.push_back(style); }
        static bool IsTransientStyle(const lv_style_t* style) { return std::find(transientStyles.begin(),transientStyles.end(),style)!=transientStyles.end(); }

        static json Read(lv_obj_t* object)
        {
#ifdef LV_RUNTIME_PORTABLE
            auto* saved = static_cast<ObjectUserData*>(lv_obj_get_user_data(object));
            return saved ? saved->objectJson.value("base", json::object()).value("nativeStyles", json::array()) : json::array();
#else
            auto result = json::array();
            std::map<uint32_t, json> selectors;
            // LVGL stores higher-priority styles first. Merge from the back so
            // explicitly applied styles retain their precedence for every state.
            for (int index = object->style_cnt - 1; index >= 0; --index)
            {
                const auto& entry = object->styles[index];
                if (
#if LV_VERSION_CHECK(9, 2, 0)
                    entry.is_theme || entry.is_disabled ||
#endif
                    entry.is_trans ||
                    std::find(transientStyles.begin(), transientStyles.end(), entry.style) != transientStyles.end()) continue;
                auto& values = selectors[entry.selector];
                if (!values.is_object()) values = json::object();
                for (const auto& property : properties)
                {
                    lv_style_value_t value;
#if LVSERIAL_USE_ADVANCED_KEYBOARD
                    bool existed = false;
                    if (entry.is_local && entry.selector == LV_PART_MAIN &&
                        espos::keyboard::authored_keyboard_style(object, property.id, existed, value)) {
                        if (existed) values[property.name] = value.num;
                        continue;
                    }
#endif
                    if (lv_style_get_prop(entry.style, property.id, &value) == LV_STYLE_RES_FOUND)
                        values[property.name] = property.color ? json(lv_color_to_u32(value.color)) : json(value.num);
                }
                lv_style_value_t font;
                if (lv_style_get_prop(entry.style, LV_STYLE_TEXT_FONT, &font) == LV_STYLE_RES_FOUND && font.ptr)
                    values["text_font"] = font.ptr == LV_FONT_DEFAULT ? json("default") : LVFont::ToJSON(*static_cast<const lv_font_t*>(font.ptr));
                for (const auto& image : {std::make_pair("bg_image_src", LV_STYLE_BG_IMAGE_SRC), std::make_pair("arc_image_src", LV_STYLE_ARC_IMAGE_SRC)
#if LVGL_VERSION_MAJOR >= 9
                    , std::make_pair("bitmap_mask_src", LV_STYLE_BITMAP_MASK_SRC)
#endif
})
                {
                    lv_style_value_t source;
                    if (lv_style_get_prop(entry.style, image.second, &source) == LV_STYLE_RES_FOUND)
                        values[image.first] = SaveImageSourceRecord(source.ptr);
                }
#if !LVSERIAL_MINIMAL_RUNTIME || LV_USE_GRID
                for (const auto& grid : {std::make_pair("grid_column_dsc_array", LV_STYLE_GRID_COLUMN_DSC_ARRAY), std::make_pair("grid_row_dsc_array", LV_STYLE_GRID_ROW_DSC_ARRAY)})
                {
                    lv_style_value_t tracks;
                    if (lv_style_get_prop(entry.style, grid.second, &tracks) != LV_STYLE_RES_FOUND || !tracks.ptr) continue;
                    auto& array = values[grid.first] = json::array();
                    const auto* sizes = static_cast<const int32_t*>(tracks.ptr);
                    while (*sizes != LV_GRID_TEMPLATE_LAST) array.push_back(*sizes++);
                }
#endif
                lv_style_value_t gradient;
                if (lv_style_get_prop(entry.style, LV_STYLE_BG_GRAD, &gradient) == LV_STYLE_RES_FOUND && gradient.ptr)
                {
                    const auto& source = *static_cast<const lv_grad_dsc_t*>(gradient.ptr);
                    auto& saved = values["bg_grad"];
                    saved = {{"direction", int(source.dir)}, {"extend",
#if LV_VERSION_CHECK(9, 2, 0)
                        int(source.extend)
#else
                        0
#endif
                    }, {"stops", json::array()}};
                    for (uint32_t i = 0; i < source.stops_count && i < LV_GRADIENT_MAX_STOPS; ++i)
                        saved["stops"].push_back({{"color", lv_color_to_u32(source.stops[i].color)}, {"opacity", source.stops[i].opa}, {"fraction", source.stops[i].frac}});
#if LV_VERSION_CHECK(9, 6, 0) || (LV_VERSION_CHECK(9, 2, 0) && LV_USE_DRAW_SW_COMPLEX_GRADIENTS)
                    auto point = [](lv_point_t p) { return json::array({p.x, p.y}); };
                    if (source.dir == LV_GRAD_DIR_LINEAR) saved["points"] = {point(source.params.linear.start), point(source.params.linear.end)};
                    else if (source.dir == LV_GRAD_DIR_RADIAL) saved["points"] = {point(source.params.radial.focal), point(source.params.radial.focal_extent), point(source.params.radial.end), point(source.params.radial.end_extent)};
                    else if (source.dir == LV_GRAD_DIR_CONICAL)
                    {
                        saved["points"] = {point(source.params.conical.center)};
                        saved["startAngle"] = source.params.conical.start_angle;
                        saved["endAngle"] = source.params.conical.end_angle;
                    }
#endif
                }
            }
            for (const auto& selector : selectors)
                if (!selector.second.empty()) result.push_back({{"selector", selector.first}, {"values", selector.second}});
            return result;
        #endif
        }

        // Reused editor canvases can outlive an imported/restored document.
        // Remove snapshot properties that disappeared without disturbing attached
        // styles or host properties outside the serialization contract. Applying
        // the incoming values remains the caller's ordinary FromJSON operation.
        static void RemoveMissingLocalProperties(lv_obj_t* object, const json& snapshot)
        {
            if (!object || !snapshot.is_array()) return;
            const auto current = Read(object);
            if (!current.is_array()) return;

            std::map<uint32_t, std::set<std::string>> incoming;
            for (const auto& record : snapshot)
            {
                if (!record.is_object() || !record.contains("values") || !record["values"].is_object()) continue;
                auto& names = incoming[record.value("selector", 0u)];
                for (const auto& value : record["values"].items()) names.insert(value.key());
            }
            for (const auto& record : current)
            {
                if (!record.is_object() || !record.contains("values") || !record["values"].is_object()) continue;
                const auto selector = record.value("selector", 0u);
                const auto expected = incoming.find(selector);
                auto removeMissing = [&](const char* name, lv_style_prop_t property) {
                    if (record["values"].contains(name) &&
                        (expected == incoming.end() || !expected->second.count(name)))
                        lv_obj_remove_local_style_prop(object, property, selector);
                };
                for (const auto& property : properties) removeMissing(property.name, property.id);
                removeMissing("text_font", LV_STYLE_TEXT_FONT);
                removeMissing("bg_image_src", LV_STYLE_BG_IMAGE_SRC);
                removeMissing("arc_image_src", LV_STYLE_ARC_IMAGE_SRC);
#if LVGL_VERSION_MAJOR >= 9
                removeMissing("bitmap_mask_src", LV_STYLE_BITMAP_MASK_SRC);
#endif
#if !LVSERIAL_MINIMAL_RUNTIME || LV_USE_GRID
                removeMissing("grid_column_dsc_array", LV_STYLE_GRID_COLUMN_DSC_ARRAY);
                removeMissing("grid_row_dsc_array", LV_STYLE_GRID_ROW_DSC_ARRAY);
#endif
                removeMissing("bg_grad", LV_STYLE_BG_GRAD);
            }
        }

        static void Apply(lv_obj_t* object, const json& records)
        {
            if (!records.is_array()) return;
            for (const auto& record : records)
            {
                const auto selector = record.value("selector", 0u);
                if (!record.contains("values") || !record["values"].is_object()) continue;
                for (const auto& property : properties)
                {
                    const auto value = record["values"].find(property.name);
                    if (value == record["values"].end() || !value->is_number_integer()) continue;
                    lv_style_value_t native{};
                    if (property.color) native.color = lv_color_hex(value->get<uint32_t>());
                    else native.num = value->get<int32_t>();
                    lv_obj_set_local_style_prop(object, property.id, native, selector);
                }
                const auto font = record["values"].find("text_font");
                if (font != record["values"].end())
                {
                    if (font->is_object()) lv_obj_set_style_text_font(object, &LVFont::FromJSON(*font), selector);
                    else if (*font == "default") lv_obj_set_style_text_font(object, LV_FONT_DEFAULT, selector);
                }
                for (const auto& image : {std::make_pair("bg_image_src", LV_STYLE_BG_IMAGE_SRC), std::make_pair("arc_image_src", LV_STYLE_ARC_IMAGE_SRC)
#if LVGL_VERSION_MAJOR >= 9
                    , std::make_pair("bitmap_mask_src", LV_STYLE_BITMAP_MASK_SRC)
#endif
})
                {
                    const auto saved = record["values"].find(image.first);
                    if (saved == record["values"].end()) continue;
                    auto& source = WidgetData<OwnedStyleData>(object).images[{selector, image.second}];
                    lv_style_value_t value{};
                    value.ptr = RestoreImageSourceRecord(*saved, source);
                    lv_obj_set_local_style_prop(object, image.second, value, selector);
                }
#if !LVSERIAL_MINIMAL_RUNTIME || LV_USE_GRID
                for (const bool columns : {true, false})
                {
                    const auto name = columns ? "grid_column_dsc_array" : "grid_row_dsc_array";
                    const auto tracks = record["values"].find(name);
                    if (tracks == record["values"].end() || !tracks->is_array()) continue;
                    auto& storage = WidgetData<OwnedStyleData>(object);
                    auto& sizes = columns ? storage.columns[selector] : storage.rows[selector];
                    sizes = tracks->get<std::vector<RuntimeStyleCoordinate>>();
                    sizes.push_back(LV_GRID_TEMPLATE_LAST);
                    if (columns) lv_obj_set_style_grid_column_dsc_array(object, sizes.data(), selector);
                    else lv_obj_set_style_grid_row_dsc_array(object, sizes.data(), selector);
                }
#endif
                const auto savedGradient = record["values"].find("bg_grad");
                if (savedGradient != record["values"].end() && savedGradient->is_object())
                {
                    const auto& saved = *savedGradient;
                    auto& gradient = WidgetData<OwnedStyleData>(object).gradients[selector];
#if !LV_VERSION_CHECK(9, 6, 0) && !LV_USE_DRAW_SW_COMPLEX_GRADIENTS
                    if(saved.contains("points") || saved.value("direction",0)>2)throw std::invalid_argument("Enable LV_USE_DRAW_SW_COMPLEX_GRADIENTS for this project");
#endif
                    gradient = {};
                    gradient.dir = static_cast<lv_grad_dir_t>(saved.value("direction", 0));
#if LV_VERSION_CHECK(9, 2, 0)
                    gradient.extend = static_cast<lv_grad_extend_t>(saved.value("extend", 0));
#endif
                    if (saved.contains("stops")) for (const auto& stop : saved["stops"])
                    {
                        if (gradient.stops_count >= LV_GRADIENT_MAX_STOPS) break;
                        auto& target = gradient.stops[gradient.stops_count++];
                        target.color = lv_color_hex(stop.value("color", 0u));
#if LVGL_VERSION_MAJOR >= 9
                        target.opa = stop.value("opacity", 255);
#endif
                        target.frac = stop.value("fraction", 0);
                    }
#if LV_VERSION_CHECK(9, 6, 0) || (LV_VERSION_CHECK(9, 2, 0) && LV_USE_DRAW_SW_COMPLEX_GRADIENTS)
                    auto point = [&saved](size_t i) {
                        const auto points = saved.find("points");
                        if (points == saved.end() || !points->is_array() || i >= points->size()) return lv_point_t{0, 0};
                        return lv_point_t{(*points)[i][0].get<int32_t>(), (*points)[i][1].get<int32_t>()};
                    };
                    if (gradient.dir == LV_GRAD_DIR_LINEAR) { gradient.params.linear.start = point(0); gradient.params.linear.end = point(1); }
                    else if (gradient.dir == LV_GRAD_DIR_RADIAL)
                    {
                        gradient.params.radial.focal = point(0); gradient.params.radial.focal_extent = point(1);
                        gradient.params.radial.end = point(2); gradient.params.radial.end_extent = point(3);
                    }
                    else if (gradient.dir == LV_GRAD_DIR_CONICAL)
                    {
                        gradient.params.conical.center = point(0);
                        gradient.params.conical.start_angle = saved.value("startAngle", 0); gradient.params.conical.end_angle = saved.value("endAngle", 3600);
                    }
#endif
                    lv_obj_set_style_bg_grad(object, &gradient, selector);
                }
            }
        }
    };
    class NativeFlags
    {
        struct Flag { const char* name; bool (*read)(const lv_obj_t*); void (*write)(lv_obj_t*, bool); };
        inline static const Flag flags[] = {
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"hidden", lv_obj_is_hidden, lv_obj_set_hidden},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"clickable", lv_obj_is_clickable, lv_obj_set_clickable},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"click_focusable", lv_obj_is_click_focusable, lv_obj_set_click_focusable},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"checkable", lv_obj_is_checkable, lv_obj_set_checkable},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scrollable", lv_obj_is_scrollable, lv_obj_set_scrollable},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_elastic", lv_obj_is_scroll_elastic, lv_obj_set_scroll_elastic},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_momentum", lv_obj_is_scroll_momentum, lv_obj_set_scroll_momentum},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_one", lv_obj_is_scroll_one, lv_obj_set_scroll_one},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_chain_hor", lv_obj_is_scroll_chain_hor, lv_obj_set_scroll_chain_hor},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_chain_ver", lv_obj_is_scroll_chain_ver, lv_obj_set_scroll_chain_ver},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_on_focus", lv_obj_is_scroll_on_focus, lv_obj_set_scroll_on_focus},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"scroll_with_arrow", lv_obj_is_scroll_with_arrow, lv_obj_set_scroll_with_arrow},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"snappable", lv_obj_is_snappable, lv_obj_set_snappable},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"press_lock", lv_obj_is_press_lock, lv_obj_set_press_lock},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"event_bubble", lv_obj_is_event_bubble, lv_obj_set_event_bubble},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"gesture_bubble", lv_obj_is_gesture_bubble, lv_obj_set_gesture_bubble},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"adv_hittest", lv_obj_is_adv_hittest, lv_obj_set_adv_hittest},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"ignore_layout", lv_obj_is_ignore_layout, lv_obj_set_ignore_layout},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"floating", lv_obj_is_floating, lv_obj_set_floating},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1)
            {"send_draw_task_events", lv_obj_is_send_draw_task_events, lv_obj_set_send_draw_task_events},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"overflow_visible", lv_obj_is_overflow_visible, lv_obj_set_overflow_visible},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"event_trickle", lv_obj_is_event_trickle, lv_obj_set_event_trickle},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5)
            {"state_trickle", lv_obj_is_state_trickle, lv_obj_set_state_trickle},
#endif
#if LV_VERSION_CHECK(9, 6, 0)
            {"radio_button", lv_obj_is_radio_button, lv_obj_set_radio_button},
#endif
#if LV_VERSION_CHECK(9, 6, 0) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 5) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 3) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 2) || (LVGL_VERSION_MAJOR == 9 && LVGL_VERSION_MINOR == 1) || (LVGL_VERSION_MAJOR == 8 && LVGL_VERSION_MINOR == 3)
            {"flex_in_new_track", lv_obj_is_flex_in_new_track, lv_obj_set_flex_in_new_track},
#endif
            {"checked", lv_obj_is_checked, lv_obj_set_checked},
            {"disabled", lv_obj_is_disabled, lv_obj_set_disabled},
            {"state_user_1", lv_obj_is_state_user_1, lv_obj_set_state_user_1},
            {"state_user_2", lv_obj_is_state_user_2, lv_obj_set_state_user_2},
            {"state_user_3", lv_obj_is_state_user_3, lv_obj_set_state_user_3},
            {"state_user_4", lv_obj_is_state_user_4, lv_obj_set_state_user_4},
        };
    public:
        static json Read(lv_obj_t* object)
        {
            json values = json::object();
            for (const auto& flag : flags) values[flag.name] = flag.read(object);
            return values;
        }
        static void Apply(lv_obj_t* object, const json& values)
        {
            if (!values.is_object()) return;
            for (const auto& flag : flags)
            {
                const auto value = values.find(flag.name);
                if (value != values.end() && value->is_boolean()) flag.write(object, value->get<bool>());
            }
        }
    };

}
#endif
